# Keil uVision project freertos.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: freertos
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\freertos\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
  group freertos/src
    ../freertos/src/: list.c task.c
  group freertos/port
    ../freertos/portable/RVDS/ARM_CM3/: port.c
  group freertos/inc
    ../freertos/inc/: FreeRTOS.h FreeRTOSConfig.h list.h portable.h portmacro.h projdefs.h task.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
